# Keil uVision project CtrlBoard-H7_IMU.uvprojx, settings and files
target CtrlBoard-H7_IMU (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00050000) IROM(0x08000000,0x00100000) XRAM(0x30000000,0x00008000) XRAM2(0x38000000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: CtrlBoard-H7_IMU +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H723xx
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Drivers/CMSIS/DSP/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../User/Algorithm/EKF;../User/Algorithm/kalman;../User/Algorithm/mahony;../User/Algorithm/Arm;../User/APP;../User/APP/Arm;../User/Bsp;../User/Devices/BMI088;../User/Devices/DM_Motor;../User/Devices/Motor;../User/Algorithm/VMC;../User/Controller;../User/Lib;../User/Algorithm/PID
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x8000
  memory RVCT7: RAM 0x38000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c freertos.c dma.c fdcan.c spi.c tim.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Device
    ../User/Devices/BMI088/: BMI088driver.c BMI088Middleware.c
    ../User/Devices/DM_Motor/: dm4310_drv.c
    ../User/Devices/Motor/: motor.c motor_manager.c motor_dm.c
  group Algorithm
    ../User/Algorithm/mahony/: mahony_filter.c
    ../User/Algorithm/EKF/: QuaternionEKF.c
    ../User/Algorithm/VMC/: VMC_calc.c
    ../User/Algorithm/kalman/: kalman_filter.c
    ../User/Lib/: user_lib.c
    ../User/Algorithm/PID/: pid.c
    ../User/Algorithm/Arm/: arm_limit.c arm_algorithm.c
  group DSP
    ../Drivers/CMSIS/DSP/Lib/ARM/: arm_cortexM7lfdp_math.lib
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group APP
    ../User/APP/: INS_task.c chassisL_task.c chassisR_task.c observe_task.c ps2_task.c ps2_link_guard.h gamepad_task.c gamepad_task.h gamepad_link_protocol.h remote_input_config.h robot_config.h
    ../User/APP/Arm/: arm_task.c arm_config.c
  group bsp
    ../User/bsp/: bsp_dwt.c
    ../User/Bsp/: can_bsp.c bsp_PWM.c
  group Controller
    ../User/Controller/: controller.c
software components: CMSIS:CORE 5.5.0
